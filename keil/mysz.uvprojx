# Keil uVision project mysz.uvprojx, settings and files
target CMSIS-DAP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL43Z256VLH4 NXP
  pack: NXP.MKL43Z4_DFP.10.0.0
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: mysz
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./: main.c extra.c leds.c slcd.c gpio.c gpio.h
software components: CMSIS:CORE 5.0.1, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:port 2.0.2, Device:Startup 1.0.0
